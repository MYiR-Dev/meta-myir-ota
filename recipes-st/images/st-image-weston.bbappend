#
# INSTALL addons for dev images
#
IMAGE_INSTALL:append = "     \
    rauc                     \
    rauc-hawkbit             \
    rauc-hawkbit-service     \
    rauc-service             \
    devmem2                  \
    fwu-gen-metadata         \
"
