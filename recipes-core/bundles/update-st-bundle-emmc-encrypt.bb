inherit bundle
RAUC_BUNDLE_COMPATIBLE = "stm32mpu"
RAUC_BUNDLE_SLOTS = "fip bootfs vendorfs rootfs"
RAUC_BUNDLE_FORMAT = "verity"
RAUC_SLOT_bootfs = "st-image-bootfs"
RAUC_SLOT_bootfs[fstype] = "ext4"
RAUC_SLOT_bootfs[type] = "image"
RAUC_SLOT_bootfs[file] = "st-image-bootfs-openstlinux-weston-myd-lf25x.bootfs.ext4"
RAUC_SLOT_rootfs = "myir-image-full"
RAUC_SLOT_rootfs[fstype] = "ext4"
RAUC_SLOT_rootfs[type] = "image"
RAUC_SLOT_rootfs[file] = "myir-image-full-openstlinux-weston-myd-lf25x.rootfs.ext4"
RAUC_SLOT_vendorfs = "st-image-vendorfs"
RAUC_SLOT_vendorfs[fstype] = "ext4"
RAUC_SLOT_vendorfs[type] = "image"
RAUC_SLOT_vendorfs[file] = "st-image-vendorfs-openstlinux-weston-myd-lf25x.vendorfs.ext4"
RAUC_SLOT_fip = "tf-a-stm32mp"
RAUC_SLOT_fip[fstype] = "raw"
RAUC_SLOT_fip[type] = "boot"
RAUC_SLOT_fip[file] = "fip/fip-myb-stm32mp257x-1GB-optee-emmc_Encrypted_Signed.bin"
RAUC_SLOT_fip[rename] = "fip-myb-stm32mp257x-1GB-optee-emmc_Encrypted_Signed.bin"
RAUC_KEY_FILE = "${THISDIR}/files/development-1.key.pem"
RAUC_CERT_FILE = "${THISDIR}/files/development-1.cert.pem"
